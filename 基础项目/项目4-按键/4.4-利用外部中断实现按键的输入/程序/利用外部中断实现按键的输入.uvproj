# Keil uVision project 利用外部中断实现按键的输入.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: 利用外部中断实现按键的输入 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: 利用外部中断实现按键的输入.c
